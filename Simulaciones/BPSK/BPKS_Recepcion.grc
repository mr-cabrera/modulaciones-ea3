options:
  parameters:
    author: Matias Gandino
    generate_options: qt_gui
    id: BPKS_Recepcion
    output_language: python
    title: BPKS_Recepcion
  states: {}

blocks:
- name: f_portadora
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: n_p_time
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: f_portadora*100
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f_portadora
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2000'
    decim: '1'
    gain: '1'
    samp_rate: '192000'
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: DEMODULACION
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: n_p_time
    srate: samp_rate
    type: float
    ymin: '0'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Portadora
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Signal_BPSK
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: Portadora
  states: {}

connections:
- [analog_sig_source_x_0, '0', virtual_sink_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', low_pass_filter_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [low_pass_filter_0, '0', digital_binary_slicer_fb_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0_0_0, '0']
- [virtual_source_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
